SRC_URI:ugoos-am6=" \
	http://fstrcmp.sourceforge.net/fstrcmp-${PV}.D001.tar.gz \
	file://nopdf.patch \
"
