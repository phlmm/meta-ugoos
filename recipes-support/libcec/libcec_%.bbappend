FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SOLIBS = ""
FILES_SOLIBSDEV = ""
