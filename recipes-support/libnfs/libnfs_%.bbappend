FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRCREV = "${AUTOREV}"
