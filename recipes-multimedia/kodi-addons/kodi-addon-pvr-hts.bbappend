SRC_URI = "git://github.com/kodi-pvr/pvr.hts.git;branch=${KODICODENAME};protocol=https"
SRCREV = "${AUTOREV}"
