SRC_URI = "git://github.com/kodi-pvr/pvr.plutotv.git;branch=${KODICODENAME};protocol=https"
SRCREV = "${AUTOREV}"
PV = "${SRCPV}"
