SRC_URI = "git://github.com/xbmc/peripheral.joystick.git;branch=Nexus;protocol=https"
SRCREV= "${AUTOREV}"
