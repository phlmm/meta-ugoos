FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += " \
file://amlogic-0001-WIP-add-confs-for-gx-sound-card-and-axg-sound-card.patch \
file://amlogic-0002-WIP-add-Amlogic-cards-to-Makefile.am.patch \
file://amlogic-0003-WIP-add-analogue-surrounds-to-confs.patch \
"
