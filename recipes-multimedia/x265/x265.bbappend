SRC_URI:remove:ugoos-am6 = "git://github.com/videolan/x265.git;protocol=https;nobranch=1"
SRC_URI:ugoos-am6 = "git://github.com/videolan/x265.git;protocol=https;branch=master"
SRCREV:ugoos-am6 = "${AUTOREV}"
